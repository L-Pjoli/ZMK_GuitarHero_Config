## boards/shields/GuitarHero/Kconfig.defconfig
```kconfig
if SHIELD_GUITARHERO

# Name must be less than 16 characters long!
config ZMK_KEYBOARD_NAME
    default "Guitar Hero"

endif
```
